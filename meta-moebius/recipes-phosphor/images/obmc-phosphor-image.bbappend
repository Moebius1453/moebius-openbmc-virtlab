IMAGE_INSTALL:append = " meminfo memwatcher"
